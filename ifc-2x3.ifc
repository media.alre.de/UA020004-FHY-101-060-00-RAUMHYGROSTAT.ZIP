Properties of the parts of a building model (IFC2X3)

# File
Description: Raumhygrostat, UP, 24 VAC bis 230 VAC, 35…85 % r.H., Wechsler, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UA020004, Raumhygrostat, UP, 24 VAC bis 230 VAC, 35…85 % r.H., Wechsler
In: Raum
Description: Der Raumhygrostat ist konzipiert zur Überwachung und Regelung der relativen Feuchte, z. B. in Geschäftsräumen, Wohnungen, Wintergärten, Bädern, Schwimmbädern, EDV-Räumen und anderen Räumen mit sauberer, nichtaggressiver Umgebung. Durch die Einwirkung der relativen Feuchte auf ein Messband wird ein potentialfreier Umschaltkontakt betätigt. Die Einstellung des Sollwertes erfolgt über den an der Frontseite befindlichen Einstellknopf. Der Einstellbereich ist einschränkbar. Mit Deckelset 50 x 50 mm oder 55 x 55 mm in nahezu alle Flächenschalterprogramme adaptierbar. Passende Deckelset-Nr. JZ-021.xxx.; Classification: EC011175 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UA020004; ModelLabel: FHY 101.060#00; GlobalTradeItemNumber: 4050528057990; ProductURL: https://alre.de/produkt_UA020004
Pset_Specification - NominalLength: 0.071 m; NominalWidth: 0.071 m; NominalDepth: 0.0425 m; NetWeight: 0.059
Pset_ALRE_ETIM_Properties - Farbe: anthrazit; Breite: 71; Höhe: 71; Tiefe: 42.5; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Haarelement; Schutzart (NEMA): sonstige; Max. Spannung der Kontakte: 230; Kontaktverriegelung: no; Max. Kontaktbelastung: 5; Messbereich unterer Wert (relative Luftfeuchtigkeit): 35; Messbereich oberer Wert (relative Luftfeuchtigkeit): 85; Schaltdifferenz einstellbar: no; Ablesbar: no; ETIM-Klasse: EC011175; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UA020004.pdf
